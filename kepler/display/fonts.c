/******************************************************************************
 *
 * @file  fonts.c
 *
 * @brief Font glyph tables and text-rendering helpers.
 *
 *        FONT_SMALL (6×8) data was derived from font_5x7.h (column-major,
 *        5×7) by transposing to row-major 6×8: for each row j (0..6),
 *        row_byte[j] = ((col[k]>>j)&1) << (7-k)  for k = 0..4.
 *        Row 7 is 0x00 (blank inter-character spacing row).
 *
 *        FONT_SMALL_EXT (6×8) glyphs are hand-crafted with the diacritic
 *        in row 0 (uppercase) or row 1 (lowercase), matching the pixel style
 *        of the converted ASCII glyphs.
 *
 *        FONT_LARGE_DIGITS (24×40) are 7-segment style, 3 bytes/row.
 *        Segment row ranges: A 0-3, F+B 4-18, G 19-21, E+C 22-36, D 37-39.
 *        Pixel patterns: horizontal = {0x3F,0xFF,0xFC},
 *                        left vert  = {0xF0,0x00,0x00},
 *                        right vert = {0x00,0x00,0x0F}.
 *
 *****************************************************************************/

#include "fonts.h"
#include <stddef.h>

/*==========================================================================*
 *  Large font — digits 0-9 (24×40)                                        *
 *==========================================================================*/

const uint8_t FONT_LARGE_DIGITS[10][FONT_LARGE_GLYPH_BYTES] = {
    /* digit 0  A B C D E F */
    {
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,  /* A */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,  /* F+B */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0x00,0x00,0x00, 0x00,0x00,0x00, 0x00,0x00,0x00,                   /* G: off */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,  /* E+C */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* D */
    },
    /* digit 1  B C */
    {
        0x00,0x00,0x00, 0x00,0x00,0x00, 0x00,0x00,0x00, 0x00,0x00,0x00,  /* A: off */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,  /* B */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x00, 0x00,0x00,0x00, 0x00,0x00,0x00,                   /* G: off */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,  /* C */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x00, 0x00,0x00,0x00, 0x00,0x00,0x00,                   /* D: off */
    },
    /* digit 2  A B D E G */
    {
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,  /* A */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,  /* B */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* G */
        0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00,  /* E */
        0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00,
        0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00,
        0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* D */
    },
    /* digit 3  A B C D G */
    {
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,  /* A */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,  /* B */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* G */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,  /* C */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* D */
    },
    /* digit 4  B C F G */
    {
        0x00,0x00,0x00, 0x00,0x00,0x00, 0x00,0x00,0x00, 0x00,0x00,0x00,  /* A: off */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,  /* F+B */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* G */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,  /* C */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x00, 0x00,0x00,0x00, 0x00,0x00,0x00,                   /* D: off */
    },
    /* digit 5  A C D F G */
    {
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,  /* A */
        0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00,  /* F */
        0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00,
        0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00,
        0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* G */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,  /* C */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* D */
    },
    /* digit 6  A C D E F G */
    {
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,  /* A */
        0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00,  /* F */
        0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00,
        0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00,
        0xF0,0x00,0x00, 0xF0,0x00,0x00, 0xF0,0x00,0x00,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* G */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,  /* E+C */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* D */
    },
    /* digit 7  A B C */
    {
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,  /* A */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,  /* B */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x00, 0x00,0x00,0x00, 0x00,0x00,0x00,                   /* G: off */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,  /* C */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x00, 0x00,0x00,0x00, 0x00,0x00,0x00,                   /* D: off */
    },
    /* digit 8  A B C D E F G */
    {
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,  /* A */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,  /* F+B */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* G */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,  /* E+C */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* D */
    },
    /* digit 9  A B C D F G */
    {
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,  /* A */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,  /* F+B */
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0xF0,0x00,0x0F, 0xF0,0x00,0x0F, 0xF0,0x00,0x0F,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* G */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,  /* C */
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x00,0x00,0x0F, 0x00,0x00,0x0F, 0x00,0x00,0x0F,
        0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC, 0x3F,0xFF,0xFC,                   /* D */
    },
};

/*==========================================================================*
 *  Large font — colon glyph (12×40)                                       *
 *==========================================================================*/
/* 2 bytes per row: byte0 cols 0-7, byte1 cols 8-11 (bits 7-4).            *
 * Dots occupy cols 4-7 (byte0 bits 3-0 = 0x0F) at rows 12-15 and 24-27.  */

const uint8_t FONT_LARGE_COLON[FONT_LARGE_H * 2u] = {
    0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00,  /* rows  0- 3 */
    0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00,  /* rows  4- 7 */
    0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00,  /* rows  8-11 */
    0x0F,0x00, 0x0F,0x00, 0x0F,0x00, 0x0F,0x00,  /* rows 12-15: upper dot */
    0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00,  /* rows 16-19 */
    0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00,  /* rows 20-23 */
    0x0F,0x00, 0x0F,0x00, 0x0F,0x00, 0x0F,0x00,  /* rows 24-27: lower dot */
    0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00,  /* rows 28-31 */
    0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00,  /* rows 32-35 */
    0x00,0x00, 0x00,0x00, 0x00,0x00, 0x00,0x00,  /* rows 36-39 */
};

/*==========================================================================*
 *  Small font — ASCII 0x20-0x7E (6×8)                                     *
 *==========================================================================*/
/* Derived from font_5x7.h (column-major 5×7) by transposing to row-major. *
 * Entries for {|}~ (indices 91-94) default to space (not in source font).  */

const uint8_t FONT_SMALL[FONT_SMALL_COUNT][FONT_SMALL_GLYPH_BYTES] = {
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, /* ' ' */
    {0x20,0x20,0x20,0x20,0x00,0x00,0x20,0x00}, /* '!' */
    {0x50,0x50,0x50,0x00,0x00,0x00,0x00,0x00}, /* '"' */
    {0x50,0x50,0xF8,0x50,0xF8,0x50,0x50,0x00}, /* '#' */
    {0x20,0x78,0xA0,0x70,0x28,0xF0,0x20,0x00}, /* '$' */
    {0xC0,0xC8,0x10,0x20,0x40,0x98,0x18,0x00}, /* '%' */
    {0x60,0x90,0xA0,0x40,0xA8,0x90,0x68,0x00}, /* '&' */
    {0x60,0x20,0x40,0x00,0x00,0x00,0x00,0x00}, /* '\'' */
    {0x10,0x20,0x40,0x40,0x40,0x20,0x10,0x00}, /* '(' */
    {0x40,0x20,0x10,0x10,0x10,0x20,0x40,0x00}, /* ')' */
    {0x00,0x20,0xA8,0x70,0xA8,0x20,0x00,0x00}, /* '*' */
    {0x00,0x20,0x20,0xF8,0x20,0x20,0x00,0x00}, /* '+' */
    {0x00,0x00,0x00,0x00,0x60,0x20,0x40,0x00}, /* ',' */
    {0x00,0x00,0x00,0xF8,0x00,0x00,0x00,0x00}, /* '-' */
    {0x00,0x00,0x00,0x00,0x00,0x60,0x60,0x00}, /* '.' */
    {0x00,0x08,0x10,0x20,0x40,0x80,0x00,0x00}, /* '/' */
    {0x70,0x88,0x98,0xA8,0xC8,0x88,0x70,0x00}, /* '0' */
    {0x20,0x60,0x20,0x20,0x20,0x20,0x70,0x00}, /* '1' */
    {0x70,0x88,0x08,0x10,0x20,0x40,0xF8,0x00}, /* '2' */
    {0xF8,0x10,0x20,0x10,0x08,0x88,0x70,0x00}, /* '3' */
    {0x10,0x30,0x50,0x90,0xF8,0x10,0x10,0x00}, /* '4' */
    {0xF8,0x80,0x80,0x70,0x08,0x88,0x70,0x00}, /* '5' */
    {0x30,0x40,0x80,0xF0,0x88,0x88,0x70,0x00}, /* '6' */
    {0xF8,0x08,0x10,0x20,0x40,0x40,0x40,0x00}, /* '7' */
    {0x70,0x88,0x88,0x70,0x88,0x88,0x70,0x00}, /* '8' */
    {0x70,0x88,0x88,0x78,0x08,0x10,0x60,0x00}, /* '9' */
    {0x00,0x60,0x60,0x00,0x60,0x60,0x00,0x00}, /* ':' */
    {0x00,0x60,0x60,0x00,0x60,0x20,0x40,0x00}, /* ';' */
    {0x10,0x20,0x40,0x80,0x40,0x20,0x10,0x00}, /* '<' */
    {0x00,0x00,0xF8,0x00,0xF8,0x00,0x00,0x00}, /* '=' */
    {0x40,0x20,0x10,0x08,0x10,0x20,0x40,0x00}, /* '>' */
    {0x70,0x88,0x08,0x10,0x20,0x00,0x20,0x00}, /* '?' */
    {0x70,0x88,0x08,0x68,0xA8,0xA8,0x70,0x00}, /* '@' */
    {0x70,0x88,0x88,0x88,0xF8,0x88,0x88,0x00}, /* 'A' */
    {0xF0,0x88,0x88,0xF0,0x88,0x88,0xF0,0x00}, /* 'B' */
    {0x70,0x88,0x80,0x80,0x80,0x88,0x70,0x00}, /* 'C' */
    {0xE0,0x90,0x88,0x88,0x88,0x90,0xE0,0x00}, /* 'D' */
    {0xF8,0x80,0x80,0xF0,0x80,0x80,0xF8,0x00}, /* 'E' */
    {0xF8,0x80,0x80,0xF0,0x80,0x80,0x80,0x00}, /* 'F' */
    {0x70,0x88,0x80,0xB8,0x88,0x88,0x78,0x00}, /* 'G' */
    {0x88,0x88,0x88,0xF8,0x88,0x88,0x88,0x00}, /* 'H' */
    {0x70,0x20,0x20,0x20,0x20,0x20,0x70,0x00}, /* 'I' */
    {0x38,0x10,0x10,0x10,0x10,0x90,0x60,0x00}, /* 'J' */
    {0x88,0x90,0xA0,0xC0,0xA0,0x90,0x88,0x00}, /* 'K' */
    {0x80,0x80,0x80,0x80,0x80,0x80,0xF8,0x00}, /* 'L' */
    {0x88,0xD8,0xA8,0xA8,0x88,0x88,0x88,0x00}, /* 'M' */
    {0x88,0x88,0xC8,0xA8,0x98,0x88,0x88,0x00}, /* 'N' */
    {0x70,0x88,0x88,0x88,0x88,0x88,0x70,0x00}, /* 'O' */
    {0xF0,0x88,0x88,0xF0,0x80,0x80,0x80,0x00}, /* 'P' */
    {0x70,0x88,0x88,0x88,0xA8,0x90,0x68,0x00}, /* 'Q' */
    {0xF0,0x88,0x88,0xF0,0xA0,0x90,0x88,0x00}, /* 'R' */
    {0x78,0x80,0x80,0x70,0x08,0x08,0xF0,0x00}, /* 'S' */
    {0xF8,0x20,0x20,0x20,0x20,0x20,0x20,0x00}, /* 'T' */
    {0x88,0x88,0x88,0x88,0x88,0x88,0x70,0x00}, /* 'U' */
    {0x88,0x88,0x88,0x88,0x88,0x50,0x20,0x00}, /* 'V' */
    {0x88,0x88,0x88,0xA8,0xA8,0xA8,0x50,0x00}, /* 'W' */
    {0x88,0x88,0x50,0x20,0x50,0x88,0x88,0x00}, /* 'X' */
    {0x88,0x88,0x88,0x50,0x20,0x20,0x20,0x00}, /* 'Y' */
    {0xF8,0x08,0x10,0x20,0x40,0x80,0xF8,0x00}, /* 'Z' */
    {0xE0,0x80,0x80,0x80,0x80,0x80,0xE0,0x00}, /* '[' */
    {0x00,0x80,0x40,0x20,0x10,0x08,0x00,0x00}, /* '\\' */
    {0x70,0x10,0x10,0x10,0x10,0x10,0x70,0x00}, /* ']' */
    {0x20,0x50,0x88,0x00,0x00,0x00,0x00,0x00}, /* '^' */
    {0x00,0x00,0x00,0x00,0x00,0x00,0xF8,0x00}, /* '_' */
    {0x40,0x20,0x10,0x00,0x00,0x00,0x00,0x00}, /* '`' */
    {0x00,0x00,0x70,0x08,0x78,0x88,0x78,0x00}, /* 'a' */
    {0x80,0x80,0xB0,0xC8,0x88,0x88,0xF0,0x00}, /* 'b' */
    {0x00,0x00,0x70,0x80,0x80,0x88,0x70,0x00}, /* 'c' */
    {0x08,0x08,0x68,0x98,0x88,0x88,0x78,0x00}, /* 'd' */
    {0x00,0x00,0x70,0x88,0xF8,0x80,0x70,0x00}, /* 'e' */
    {0x30,0x48,0x40,0xE0,0x40,0x40,0x40,0x00}, /* 'f' */
    {0x00,0x78,0x88,0x88,0x78,0x08,0x70,0x00}, /* 'g' */
    {0x80,0x80,0xB0,0xC8,0x88,0x88,0x88,0x00}, /* 'h' */
    {0x20,0x00,0x60,0x20,0x20,0x20,0x70,0x00}, /* 'i' */
    {0x10,0x00,0x30,0x10,0x10,0x90,0x60,0x00}, /* 'j' */
    {0x80,0x80,0x90,0xA0,0xC0,0xA0,0x90,0x00}, /* 'k' */
    {0x60,0x20,0x20,0x20,0x20,0x20,0x70,0x00}, /* 'l' */
    {0x00,0x00,0xD0,0xA8,0xA8,0x88,0x88,0x00}, /* 'm' */
    {0x00,0x00,0xB0,0xC8,0x88,0x88,0x88,0x00}, /* 'n' */
    {0x00,0x00,0x70,0x88,0x88,0x88,0x70,0x00}, /* 'o' */
    {0x00,0x00,0xF0,0x88,0xF0,0x80,0x80,0x00}, /* 'p' */
    {0x00,0x00,0x68,0x98,0x78,0x08,0x08,0x00}, /* 'q' */
    {0x00,0x00,0xB0,0xC8,0x80,0x80,0x80,0x00}, /* 'r' */
    {0x00,0x00,0x70,0x80,0x70,0x08,0xF0,0x00}, /* 's' */
    {0x40,0x40,0xE0,0x40,0x40,0x48,0x30,0x00}, /* 't' */
    {0x00,0x00,0x88,0x88,0x88,0x98,0x68,0x00}, /* 'u' */
    {0x00,0x00,0x88,0x88,0x88,0x50,0x20,0x00}, /* 'v' */
    {0x00,0x00,0x88,0x88,0xA8,0xA8,0x50,0x00}, /* 'w' */
    {0x00,0x00,0x88,0x50,0x20,0x50,0x88,0x00}, /* 'x' */
    {0x00,0x00,0x88,0x88,0x78,0x08,0x70,0x00}, /* 'y' */
    {0x00,0x00,0xF8,0x10,0x20,0x40,0xF8,0x00}, /* 'z' */
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, /* '{' — not in source */
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, /* '|' — not in source */
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, /* '}' — not in source */
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, /* '~' — not in source */
    {0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00}, /* padding to 96 */
};

/*==========================================================================*
 *  Small extended font — Spanish + punctuation (6×8)                      *
 *==========================================================================*/
/* Diacritics occupy row 0 for uppercase, row 1 for lowercase.              *
 * Base letter pixels match the FONT_SMALL glyph pixels exactly.           */

const uint8_t FONT_SMALL_EXT[FONT_EXT_COUNT][FONT_SMALL_GLYPH_BYTES] = {
    {0x20,0x20,0x20,0x20,0x00,0x00,0x20,0x00}, /* ¡ U+00A1 */
    {0x20,0x00,0x20,0x40,0x80,0x88,0x70,0x00}, /* ¿ U+00BF */
    {0x20,0x70,0x88,0xF8,0x88,0x88,0x00,0x00}, /* Á U+00C1 */
    {0x20,0xF8,0x80,0xF0,0x80,0xF8,0x00,0x00}, /* É U+00C9 */
    {0x10,0x70,0x20,0x20,0x20,0x70,0x00,0x00}, /* Í U+00CD */
    {0x50,0x88,0x88,0xC8,0xA8,0x98,0x88,0x00}, /* Ñ U+00D1 */
    {0x20,0x70,0x88,0x88,0x88,0x70,0x00,0x00}, /* Ó U+00D3 */
    {0x20,0x88,0x88,0x88,0x88,0x70,0x00,0x00}, /* Ú U+00DA */
    {0x50,0x88,0x88,0x88,0x88,0x70,0x00,0x00}, /* Ü U+00DC */
    {0x00,0x20,0x70,0x08,0x78,0x88,0x78,0x00}, /* á U+00E1 */
    {0x00,0x20,0x70,0x88,0xF8,0x80,0x70,0x00}, /* é U+00E9 */
    {0x10,0x00,0x60,0x20,0x20,0x20,0x70,0x00}, /* í U+00ED */
    {0x00,0x50,0xB0,0xC8,0x88,0x88,0x88,0x00}, /* ñ U+00F1 */
    {0x00,0x20,0x70,0x88,0x88,0x88,0x70,0x00}, /* ó U+00F3 */
    {0x00,0x20,0x88,0x88,0x88,0x98,0x68,0x00}, /* ú U+00FA */
    {0x00,0x50,0x88,0x88,0x88,0x98,0x68,0x00}, /* ü U+00FC */
};

/*==========================================================================*
 *  UTF-8 → extended glyph lookup                                          *
 *==========================================================================*/

/* All supported codepoints fall in U+00A1..U+00FC, encoded as:            *
 *   U+0080..U+00BF → first=0xC2, second=0x80|(cp&0x3F)                   *
 *   U+00C0..U+00FF → first=0xC3, second=0x80|(cp&0x3F)                   */

typedef struct {
    uint8_t     second_byte; /* continuation byte of the 2-byte UTF-8 seq */
    font_ext_id_t ext_id;
} utf8_entry_t;

/* 0xC2 prefix: U+00A1(¡), U+00BF(¿) */
static const utf8_entry_t s_c2_table[] = {
    {0xA1, FONT_EXT_IEXCL},
    {0xBF, FONT_EXT_IQUEST},
};

/* 0xC3 prefix: U+00C1..U+00FC */
static const utf8_entry_t s_c3_table[] = {
    {0x81, FONT_EXT_A_UC},
    {0x89, FONT_EXT_E_UC},
    {0x8D, FONT_EXT_I_UC},
    {0x91, FONT_EXT_N_UC},
    {0x93, FONT_EXT_O_UC},
    {0x9A, FONT_EXT_U_UC},
    {0x9C, FONT_EXT_U_UML_UC},
    {0xA1, FONT_EXT_A_LC},
    {0xA9, FONT_EXT_E_LC},
    {0xAD, FONT_EXT_I_LC},
    {0xB1, FONT_EXT_N_LC},
    {0xB3, FONT_EXT_O_LC},
    {0xBA, FONT_EXT_U_LC},
    {0xBC, FONT_EXT_U_UML_LC},
};

/* Returns FONT_EXT_COUNT if not found. */
static font_ext_id_t lookup_utf8(uint8_t first, uint8_t second)
{
    const utf8_entry_t *table;
    uint8_t             count;
    uint8_t             i;

    if (first == 0xC2u) {
        table = s_c2_table;
        count = (uint8_t)(sizeof(s_c2_table) / sizeof(s_c2_table[0]));
    } else if (first == 0xC3u) {
        table = s_c3_table;
        count = (uint8_t)(sizeof(s_c3_table) / sizeof(s_c3_table[0]));
    } else {
        return FONT_EXT_COUNT;
    }

    for (i = 0; i < count; i++) {
        if (table[i].second_byte == second) {
            return table[i].ext_id;
        }
    }
    return FONT_EXT_COUNT;
}

/*==========================================================================*
 *  Rendering helpers                                                        *
 *==========================================================================*/

void font_draw_digit_large(sharp_fb_t fb, uint8_t x, uint8_t y, uint8_t digit)
{
    if (digit > 9u) {
        digit = 0u;
    }
    fb_draw_glyph(fb, FONT_LARGE_DIGITS[digit],
                  FONT_LARGE_W, FONT_LARGE_H, x, y, false);
}

void font_draw_colon_large(sharp_fb_t fb, uint8_t x, uint8_t y)
{
    fb_draw_glyph(fb, FONT_LARGE_COLON,
                  FONT_LARGE_COLON_W, FONT_LARGE_H, x, y, false);
}

void font_draw_char_small(sharp_fb_t fb, uint8_t x, uint8_t y,
                          char c, bool invert)
{
    uint8_t idx;
    if ((uint8_t)c < FONT_SMALL_FIRST_CHAR || (uint8_t)c > FONT_SMALL_LAST_CHAR) {
        idx = 0u; /* space */
    } else {
        idx = (uint8_t)c - FONT_SMALL_FIRST_CHAR;
    }
    fb_draw_glyph(fb, FONT_SMALL[idx], FONT_SMALL_W, FONT_SMALL_H, x, y, invert);
}

void font_draw_string(sharp_fb_t fb, uint8_t x, uint8_t y,
                      const char *str, bool invert)
{
    uint8_t cx = x;
    const uint8_t *p = (const uint8_t *)str;

    while (*p != 0u && cx + FONT_SMALL_W <= SHARP_LCD_WIDTH) {
        uint8_t b = *p;

        if (b < 0x80u) {
            /* Single-byte ASCII */
            font_draw_char_small(fb, cx, y, (char)b, invert);
            p++;
        } else if ((b & 0xE0u) == 0xC0u) {
            /* Two-byte UTF-8 sequence */
            uint8_t second = *(p + 1);
            if ((second & 0xC0u) == 0x80u) {
                font_ext_id_t id = lookup_utf8(b, second);
                if (id < FONT_EXT_COUNT) {
                    fb_draw_glyph(fb, FONT_SMALL_EXT[id],
                                  FONT_SMALL_W, FONT_SMALL_H, cx, y, invert);
                } else {
                    /* Unknown codepoint — render '?' */
                    font_draw_char_small(fb, cx, y, '?', invert);
                }
                p += 2;
            } else {
                /* Malformed: skip leader byte */
                p++;
                continue;
            }
        } else {
            /* 3/4-byte sequence or stray continuation: skip */
            p++;
            continue;
        }
        cx += FONT_SMALL_W;
    }
}

uint8_t font_string_width(const char *str)
{
    uint8_t            count = 0u;
    const uint8_t     *p     = (const uint8_t *)str;

    while (*p != 0u) {
        uint8_t b = *p;
        if (b < 0x80u) {
            count++;
            p++;
        } else if ((b & 0xE0u) == 0xC0u) {
            uint8_t second = *(p + 1);
            if ((second & 0xC0u) == 0x80u) {
                count++;
                p += 2;
            } else {
                p++;
            }
        } else {
            p++;
        }
    }
    return (uint8_t)(count * FONT_SMALL_W);
}
